Commit message: Update house.urdf

File: house.urdf (robot description, URDF)
Before this commit: robot box, 2 links, 1 joints
Links:
- removed link box
- added link house, mass 1; collision box size=.1 .2 .3; visual mesh filename=house_mesh.obj
